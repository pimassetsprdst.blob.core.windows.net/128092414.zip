Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-24T15:28:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 24 15:28:41 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\4a2a7b7e-aaa6-4ace-aaff-4e93a8de6c4c\cebae7b3-98a2-44c9-a0a2-5507eb6efa89\ifc * Database version: 5507 * Database creation date: Mon Oct 24 15:28:41 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 24 15:28:41 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 24 15:28:41 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: 2CKA001012A1069, E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001012A1069_DE-EN:2CKA001012A1069:2937041
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RGB 150-150-150
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 10 mm; Height: 71 mm; Rounding Radius: 4 mm; Width: 71 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM
Type - Identity Data - Article Code: Default; Article Description: Rocker Switch Mechanism, Inserts for flush-mounted switch ranges; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: yes; Description: Rocker Switch Mechanism, Inserts for flush-mounted switch ranges; EMCS Version: 4.0; ETIM Article Class: EC001590; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395007105; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001012A1069; Manufacturer Type: 2000/6 US; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001012A1069,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Revit Version: 2020; Type Name: 2CKA001012A1069; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001012A1069_DE-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: 2CKA001012A1069
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: 2CKA001012A1069
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00701291 m2; Volume: 0.0000522726 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 3; VERSION: 220800
Other - Family: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001012A1069_DE-EN: 2CKA001012A1069; Family and Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001012A1069_DE-EN: 2CKA001012A1069; Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001012A1069_DE-EN: 2CKA001012A1069; Type Id: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001012A1069_DE-EN: 2CKA001012A1069
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: Reflex SI_2CKA001725A0936_ver_2, E_Frame Vertical_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_DE-EN:Reflex SI_2CKA001725A0936_ver_2:2937036
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 16 mm; Gang Height: 55 mm; Gang Width: 55 mm; Height: 152 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 8 mm; Rounding Radius: 11 mm; Width: 81 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Alpine white; Material: Color RAL 9010; Number of Gangs: 2
Type - Identity Data - Article Code: Default; Article Description: Cover frame, alpine white, Frame Reflex SI; Article Type: 2-gang frame; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Cover frame, alpine white, Frame Reflex SI; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395099209; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001725A0936; Manufacturer Type: 2512-214; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001725A0936,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 2-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: Reflex SI; Revit Version: 2020; Type Name: Reflex SI_2CKA001725A0936_ver_2; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame Vertical_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_DE-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: Reflex SI_2CKA001725A0936_ver_2
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Reflex SI_2CKA001725A0936_ver_2
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0227746 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.00006065 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-200 VA
Electrical - Loads - Load Clasiffication: Power; Power: 200 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 220800
Other - Annotation Offset Position: 7 mm; Family: E_Frame Vertical_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_DE-EN: Reflex SI_2CKA001725A0936_ver_2; Family and Type: E_Frame Vertical_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_DE-EN: Reflex SI_2CKA001725A0936_ver_2; Gang 3: 71 mm; Gang Reference Line: 126 mm; Interior Width: 27.5 mm; Number of Representation Line: 2; Type: E_Frame Vertical_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_DE-EN: Reflex SI_2CKA001725A0936_ver_2; Type Id: E_Frame Vertical_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_DE-EN: Reflex SI_2CKA001725A0936_ver_2
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: Reflex SI_with Earth 1F_2CKA002011A1888, E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002011A1888_DE-EN:Reflex SI_with Earth 1F_2CKA002011A1888:2937042
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 2800 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 54 mm; Rounding Radius: 8 mm; Width: 54 mm
Type - Electrical - Material: Color RAL 9010; App ID: EL_MODELPARTSYSTEM; Insert Type: Alpine white
Type - Identity Data - Custom: no; Article Code: Default; Article Description: SCHUKO socket outlet, alpine white, Socket outlets; Article Type: Socket outlet with PE recessed 1-fold; Base Family Version: 20221003; Category: EL_POWERCONSUMER; Content Supplier URL: www.MEPcontent.com; Description: SCHUKO socket outlet, alpine white, Socket outlets; EMCS Version: 4.0; ETIM Article Class: EC000125; Family Version: 11.23; GLN: 8712507900012; GTIN: 4011395199404; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA002011A1888; Manufacturer Type: 20 EUC-214; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA002011A1888,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: Socket outlet with PE recessed 1-fold; OmniClass Number: 23.80.50.00; OmniClass Title: Terminals for Power Supply; Product Line: Reflex SI; Revit Version: 2020; Type Name: Reflex SI_with Earth 1F_2CKA002011A1888; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002011A1888_DE-EN
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: Reflex SI_with Earth 1F_2CKA002011A1888
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Reflex SI_with Earth 1F_2CKA002011A1888
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0; Annotation: 19
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.0160545 m2; Volume: 0.0000320297 m3
Electrical - Loads - Load Classification: Power; Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 6; VERSION: 220800
Other - Annotation SocketOneFoldWithEarth: yes; Family: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002011A1888_DE-EN: Reflex SI_with Earth 1F_2CKA002011A1888; Family and Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002011A1888_DE-EN: Reflex SI_with Earth 1F_2CKA002011A1888; Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002011A1888_DE-EN: Reflex SI_with Earth 1F_2CKA002011A1888; Type Id: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002011A1888_DE-EN: Reflex SI_with Earth 1F_2CKA002011A1888
Phasing - Phase Created: 4. Plan over 10 years

# IfcSwitchingDevice: Reflex SI_2-Way_2CKA001731A0876, E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001731A0876_DE-EN:Reflex SI_2-Way_2CKA001731A0876:2937040
In: F00
Type - PredefinedType: CONTACTOR; Material: Color RAL 9010
Type - Constraints - Default Elevation: 1050 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 54 mm; Rounding Radius: 8 mm; Width: 54 mm
Type - Electrical - Material: Color RAL 9010; App ID: EL_MODELPARTSYSTEM; Insert Type: Alpine white
Type - Identity Data - Custom: no; Article Code: Default; Article Description: Rocker, alpine white, Covers for switches/push-buttons; Base Family Version: 20221003; Category: EL_SINGLEPOLESWITCH; Content Supplier URL: www.MEPcontent.com; Description: Rocker, alpine white, Covers for switches/push-buttons; EMCS Version: 4.0; ETIM Article Class: EC000011; Family Version: 11.21; GLN: 8712507900012; GTIN: 4011395112601; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001731A0876; Manufacturer Type: 2506-214; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001731A0876,artikel.html; MEPcontent Class: LIGHTING_DEVICES; OmniClass Number: 23.80.00.00; OmniClass Title: Electric Power and Lighting; Product Line: Reflex SI; Revit Version: 2020; Type Name: Reflex SI_2-Way_2CKA001731A0876; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Devices; Family Name: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001731A0876_DE-EN
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: Reflex SI_2-Way_2CKA001731A0876
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_SwitchingDeviceTypeCommon - Reference: Reflex SI_2-Way_2CKA001731A0876
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Annotation: 1; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00737279 m2; Volume: 0.0000392127 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 1; VERSION: 220800
Other - Annotation SwitchTwoWay: yes; Family: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001731A0876_DE-EN: Reflex SI_2-Way_2CKA001731A0876; Family and Type: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001731A0876_DE-EN: Reflex SI_2-Way_2CKA001731A0876; Type: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001731A0876_DE-EN: Reflex SI_2-Way_2CKA001731A0876; Type Id: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001731A0876_DE-EN: Reflex SI_2-Way_2CKA001731A0876
Phasing - Phase Created: 4. Plan over 10 years
